# IAR project LIS302DL.ewp, settings and files
configuration LIS302DL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\usb_conf; ..\usb_lib\cdc; ..\usb_lib\core; ..\usb_lib\otg; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LIS302DL.srec
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group usb_conf
    Z:/Scrivania/STM32F4COM/STM32DiscoveryVCP/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
  group usb_lib/cdc
    Z:/Scrivania/STM32F4COM/STM32DiscoveryVCP/usb_lib/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
  group usb_lib/core
    Z:/Scrivania/STM32F4COM/STM32DiscoveryVCP/usb_lib/core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usb_lib/otg
    Z:/Scrivania/STM32F4COM/STM32DiscoveryVCP/usb_lib/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c vcp.c
